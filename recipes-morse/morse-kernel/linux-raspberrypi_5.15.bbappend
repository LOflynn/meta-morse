FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://morse_patches.patch \
		file://hostap_crypto.cfg \
		file://morse-ps-overlay.dts \
		"
